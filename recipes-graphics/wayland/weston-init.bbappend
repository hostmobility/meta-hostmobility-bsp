# Remove use of INI_UNCOMMENT_USE_G2D:imxgpu2d      ?= "use-g2d=1" in meta-freescale.
INI_UNCOMMENT_USE_G2D:imxgpu2d      = ""
