DESCRIPTION = "HMM customized for flash wic.gz, Boot script for launching images with U-Boot distro boot"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"